Commit message: added plane.obj

File: laboratory/Lab6/urdf/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=30 30 10; visual mesh filename=plane.obj scale=0.05 0.05 0.05
